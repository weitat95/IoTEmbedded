# Keil uVision project RTOS_TM4C123_LifiTransmitter.uvproj, settings and files
target pegasus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: pegasus
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F110B2QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s osasm.s uart.c os.c pll.c adct0atrigger.c fifo.c uart_fifo.c main.c gpio.c LifiEmitter.c LifiReceiver.c LifiReceiver.h ST7735.c eDisk.c
