# Keil uVision project IOT_RTOS_TM4C123.uvproj, settings and files
target pegasus (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: pegasus
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F110B2QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s osasm.s uart.c os.c pll.c adct0atrigger.c uart_fifo.c main.c gpio.c esp8266.c hc05.c WS2812.c DMATimer.c LEDRINGTask.c barometer.c
